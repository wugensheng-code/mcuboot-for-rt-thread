# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __RTTHREAD__, __STDC_LIMIT_MACROS, STM32H750xx, USE_HAL_DRIVER, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c include: applications;rt-thread/components/libc/compilers/common/include;rt-thread/components/libc/compilers/common/extension;rt-thread/components/libc/compilers/common/extension/fcntl/octal;rt-thread/libcpu/arm/common;rt-thread/libcpu/arm/cortex-m7;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/spi;rt-thread/components/drivers/include;rt-thread/components/drivers/touch;rt-thread/components/drivers/include;board;board/CubeMX_Config/Core/Inc;board/port;libraries/HAL_Drivers;libraries/HAL_Drivers/config;libraries/HAL_Drivers/CMSIS/Include;rt-thread/components/finsh;.;rt-thread/include;libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Inc;libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Include;rt-thread/components/libc/posix/io/poll;rt-thread/components/libc/posix/io/stdio;rt-thread/components/libc/posix/ipc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_sdram.c drv_spi.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_crc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_usart.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_pwr.c stm32h7xx_hal.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_crc.c stm32h7xx_hal_spi.c stm32h7xx_hal_rng.c stm32h7xx_hal_i2c.c stm32h7xx_hal_qspi.c stm32h7xx_hal_comp.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_uart.c
