# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32H750xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: applications; libraries/HAL_Drivers; libraries/HAL_Drivers/CMSIS/Include; libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Inc; rt-thread/components/libc/compilers/common/extension; rt-thread/components/drivers/touch; board/port; libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Include; board/CubeMX_Config/Core/Inc; rt-thread/components/libc/posix/io/stdio; rt-thread/include; .; rt-thread/components/drivers/spi; board; libraries/HAL_Drivers/config; rt-thread/components/drivers/include; rt-thread/components/libc/posix/io/poll; rt-thread/libcpu/arm/cortex-m7; rt-thread/libcpu/arm/common; rt-thread/components/libc/compilers/common/extension/fcntl/octal; rt-thread/components/libc/compilers/common/include; rt-thread/components/libc/posix/ipc; rt-thread/components/finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_sdram.c drv_spi.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sram.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma.c stm32h7xx_hal_spi.c stm32h7xx_hal_rng.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_sdram.c stm32h7xx_hal_mdma.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
